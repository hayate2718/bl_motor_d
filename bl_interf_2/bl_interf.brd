# Repository hayate2718/bl_motor_d

File README.md:

# ブラシレスモータドライバー基板
## 機能
1. FETはTO252であれば使える。ゲート抵抗とゲートソース間コンデンサを調整すること<br>
ゲートソース間コンデンサは くらいになるようにする。
2. vdsth_pinで短絡検出を行う。パルス電流の絶対最大定格時の電圧降下を入れればいいと思う。計算式は下記 

3. ref_pinで定常の電流制限を行う。計算式は下記 

4. ピンヘッダをショートすることで動作モードの切り替えが可能<br>
jp1がfフラグを無視（オープンループでリミットを完全に外す場合はさらにRCピンをショートしてください）、jp2が高速減衰モードにできる(動くときと動かんときがある)
5. untitl.txtファイルは読んでください<br>
## 制作者コメント
<b>一枚の値段がいくらになるのか考えたくもない...結果としては4000yenほど(たけぇ<br>
このMDは制御方法が台形120度通電であるため低速域よりも高速域の効率のほうが良い。<br>
モータの最大効率運転では電流波形が正弦波に近いほどよく、台形120度通電では電流波形が台形になるように制御されているが高速域では電流波形が正弦波に近くなるため効率が良くなる。</b>

## EAGLE design bl_interf_2/bl_interf.brd

Parts:
C16, C17: 0.1u; C2012
JP1, JP2: PINHD-1X8; 1X08
R1, R2, R7, R30, R31, R33, R34, R35, R36, R37: 1k; M2012
R3, R5: 9.1k; M2012
R4, R6: 4.7k; M2012
U$1: RGB_LED
U$17, U$18: TLP2395
U$19: TLP291
U$20: TLP290-4; TLP290
U$21: DF1B_L_4P
U$22: DF1B_L_6P

Connections:
AGND: C16.1, JP1.8, JP2.3, JP2.5, JP2.8, R7.2, U$17.K, U$18.GND, U$19.PIN2 (PIN2_KSODE), U$20.1_E, U$20.2_E, U$20.3_E, U$20.4_E
BRAKE: JP2.7, U$20.2_C
COAST: JP1.3, U$20.3_C
CSOUT: JP2.2
DIR: JP2.6, U$20.1_C
DIRO: JP1.2, R33.2
FFO1: JP1.5, R1.2
FFO2: JP1.6, R2.2
GNDI: C17.2, R3.2, R5.1, U$17.GND, U$18.K, U$19.PIN3 (PIN3_TR_E), U$20.1_K, U$20.2_K, U$20.3_K, U$20.4_K, U$21.PIN4, U$22.PIN6
L_BRAKE: R35.1, U$22.PIN2
L_COAST: R36.1, U$22.PIN3
L_DIR: R34.1, U$22.PIN4
L_DIRO: R3.1, R4.2, U$19.PIN4 (PIN4_TR_C), U$21.PIN2
L_PWM: R31.1, U$22.PIN5
L_RESET: R37.1, U$22.PIN1
L_TACHO: R5.2, R6.1, U$21.PIN3
unnamed: R7.1, U$1.B_K
unnamed: R1.1, U$1.R_K
unnamed: R2.1, U$1.G_K
unnamed: R30.1, U$17.A
unnamed: R31.2, U$18.A
unnamed: R6.2, U$17.OUT
unnamed: R34.2, U$20.1_A
unnamed: R33.1, U$19.PIN1 (PIN1_ANODE)
unnamed: R35.2, U$20.2_A
unnamed: R36.2, U$20.3_A
unnamed: R37.2, U$20.4_A
PWM: JP2.4, U$18.OUT
RESET: JP1.4, U$20.4_C
TACHO: JP1.7, R30.2
V5: C16.2, JP1.1, JP2.1, U$1.B_A, U$1.G_A, U$1.R_A, U$18.VCC
VIN: C17.1, R4.1, U$17.VCC, U$21.PIN1

Notes on the sheet:
4pinでモタドラからの出力を受ける。3.3vとgnd,diro,tacho
6pinでモタドラに対して入力を行う。pwmとdir,break,coast,reset,gnd

Board: 2 copper layers, 30.5 x 50.8 mm, 25 parts (13 on the bottom side), 31 nets.

## EAGLE design bl_motor_dora3/bl_dora2.brd

Parts:
C1: 220n; C2012
C2, C8: 10u; C2012
C3, C9, C11: 0.1u; C2012
C4: 0.47u; C2012
C5, C6, C7: 0.22u; C2012
C10: 680p; C2012
C12: 820u; 153CLV-1012
C13, C14, C15, C16, C17, C18: 5n; C2012
C19: 2.2n; C1608
F_C1, F_C2, F_C3, F_C4, F_C5, F_C6: FIL_CAPA
JP1, JP2: PINHD-1X2; 1X02
JP3, JP4: PINHD-1X8; 1X08
N$20N$21: 10k; M2012
R1: 0; M2012
R2, R15: 33k; M2012
R3, R4, R16, R24, R25, R27, R28, R29, R39: 10k; M2012
R5: 39k; M2012
R6, R7, R26, R30, R31, R32: 22; R1206
R8: 22k; M2012
R9: 3.3k; M2012
R10: 20k; M2012
R11, R12, R13, R14: 20m; R2512
R17: 47k; M2012
R18, R19, R20, R21, R22, R23: 10; M2012
R_I1, R_I2: 1k; 0603X4RESISTOR
U$1: A3930
U$2: 2SC5964
U$3: SSOT6_FET
U$4: RGB_LED
U$5: 10K; 1005X4RESISTOR
U$6: SMD_DAIOD
U$7, U$8, U$9, U$10, U$11, U$12: NP52N06SLG
U$13, U$14, U$15, U$16, U$17, U$18: SBR10M100P5Q
U$19: XH_2P
U$20, U$21, U$22, U$26, U$27, U$28: ES3BB13F
U$23: ZH_6P_L
U$24: XT60
U$25: VL_3P

Connections:
AGND: C1.2, C2.2, C3.2, C8.2, C9.2, C10.2, JP1.1, JP2.1, JP3.1, JP4.1, JP4.4, JP4.6, R1.1, R5.1, R9.1, R15.1, R17.1, U$1.PAD, U$1.PIN17 (PIN17_TEST), U$1.PIN41 (PIN41_AGND), U$3.2 (PIN2_S2), U$3.5 (PIN5_S1), U$4.R_K, U$5.5, U$23.PIN6
BRAKE: JP4.2, U$1.PIN8 (PIN8_BRAKE), U$5.4
COAST: JP3.6, R39.1, U$1.PIN46 (PIN46_COAST)
CSOUT: JP4.7, U$1.PIN19 (PIN19_CSOUT)
DIR: JP4.3, U$1.PIN9 (PIN9_DIR), U$5.3
DIRO: JP3.7, U$1.PIN44 (PIN44_DIRO)
ESF: JP1.2, R16.1, U$1.PIN39 (PIN39_ESF)
FFO1: U$3.6 (PIN6_D1), U$4.G_K
FFO2: U$3.4 (PIN4_D2), U$4.B_K
GND: C11.2, C12.-, R1.2, R11.1, R12.1, R13.1, R14.1, R_I2.3, R_I2.4, U$19.P$1, U$24.P$1
H1: U$1.PIN10 (PIN10_H1), U$23.PIN3
H2: U$1.PIN11 (PIN11_H2), U$23.PIN4
H3: U$1.PIN12 (PIN12_H3), U$23.PIN5
unnamed: C3.1, U$1.PIN3 (PIN3_V5BD), U$2.B
unnamed: R3.1, U$1.PIN5 (PIN5_FF2), U$3.3 (PIN3_G2)
unnamed: R4.1, U$1.PIN6 (PIN6_FF1), U$3.1 (PIN1_G1)
unnamed: R15.2, U$1.PIN18 (PIN18_RDEAD)
unnamed: F_C5.P$2 (2), R32.2, U$20.A
unnamed: C14.2, C15.2, C16.2, F_C1.P$2 (2), F_C2.P$2 (2), F_C6.P$2 (2), R11.2, R12.2, R13.2, R14.2, R27.1, R28.1, R29.1, R30.1, R31.1, R32.1, R_I2.1, R_I2.2, U$1.PIN38 (PIN38_LSS), U$8.PIN3_S, U$10.PIN3_S, U$12.PIN3_S, U$14.A1, U$14.A2, U$15.A1, U$15.A2, U$18.A1, U$18.A2
unnamed: R5.2, R8.1, U$1.PIN20 (PIN20_REF)
unnamed: C19.2, R_I2.5, R_I2.6, U$1.PIN21 (PIN21_CSN)
unnamed: R9.2, R10.1, U$1.PIN23 (PIN23_VDSTH)
unnamed: R_I1.5, U$4.R_A
unnamed: C4.1, U$1.PIN42 (PIN42_CP1)
unnamed: JP2.2, U$1.PIN15 (PIN15_MODE), U$5.2
unnamed: C4.2, U$1.PIN43 (PIN43_CP2)
unnamed: C5.1, U$1.PIN27 (PIN27_CC)
unnamed: C6.1, U$1.PIN30 (PIN30_CB)
unnamed: C7.1, U$1.PIN33 (PIN33_CA)
unnamed: C7.2, C13.2, R24.1, U$1.PIN31 (PIN31_SA), U$7.PIN3_S, U$8.PIN2_D, U$13.A1, U$13.A2, U$14.K, U$20.C, U$25.P$1 (PIN1), U$26.A
unnamed: C19.1, R_I2.7, R_I2.8, U$1.PIN22 (PIN22_CSP)
unnamed: R_I1.6, U$4.G_A
unnamed: C8.1, U$1.PIN40 (PIN40_VREG)
unnamed: C9.1, U$1.PIN45 (PIN45_VBB), U$6.K
unnamed: C10.1, R17.2, U$1.PIN16 (PIN16_RC)
unnamed: C13.1, R18.2, R24.2, U$7.PIN1_G
unnamed: C18.1, R19.2, R25.2, U$9.PIN1_G
unnamed: C17.1, N$20N$21.2, R20.2, U$11.PIN1_G
unnamed: C16.1, R21.2, R27.2, U$12.PIN1_G
unnamed: C15.1, R22.2, R28.2, U$10.PIN1_G
unnamed: C14.1, R23.2, R29.2, U$8.PIN1_G
unnamed: R23.1, U$1.PIN36 (PIN36_GLA)
unnamed: R22.1, U$1.PIN35 (PIN35_GLB)
unnamed: R21.1, U$1.PIN34 (PIN34_GLC)
unnamed: R_I1.8, U$4.B_A
unnamed: R18.1, U$1.PIN32 (PIN32_GHA)
unnamed: R19.1, U$1.PIN29 (PIN29_GHB)
unnamed: R20.1, U$1.PIN26 (PIN26_GHC)
unnamed: F_C4.P$2 (2), R31.2, U$21.A
unnamed: F_C3.P$2 (2), R30.2, U$22.A
unnamed: F_C6.P$1 (1), R6.1, U$26.C
unnamed: C5.2, C17.2, N$20N$21.1, U$1.PIN25 (PIN25_SC), U$11.PIN3_S, U$12.PIN2_D, U$17.A1, U$17.A2, U$18.K, U$22.C, U$25.P$3 (PIN3), U$28.A
unnamed: F_C1.P$1 (1), R26.1, U$28.C
unnamed: F_C2.P$1 (1), R7.1, U$27.C
unnamed: C6.2, C18.2, R25.1, U$1.PIN28 (PIN28_SB), U$9.PIN3_S, U$10.PIN2_D, U$15.K, U$16.A1, U$16.A2, U$21.C, U$25.P$2 (PIN2), U$27.A
PWM: JP4.5, U$1.PIN14 (PIN14_PWM), U$5.1
RESET: JP3.5, R2.1, U$1.PIN2 (PIN2_RESET)
TACHO: JP3.2, U$1.PIN7 (PIN7_TACHO)
V5: C1.1, C2.1, JP3.8, JP4.8, R3.2, R4.2, R8.2, R10.2, R16.2, R39.2, R_I1.1, R_I1.2, R_I1.3, R_I1.4, U$1.PIN4 (PIN4_V5), U$2.E, U$5.6, U$5.7, U$5.8, U$23.PIN1
VCC: C11.1, C12.+, F_C3.P$1 (1), F_C4.P$1 (1), F_C5.P$1 (1), R2.2, R6.2, R7.2, R26.2, U$1.PIN24 (PIN24_VDRAIN), U$2.C, U$2.C@2 (C), U$6.A, U$7.PIN2_D, U$9.PIN2_D, U$11.PIN2_D, U$13.K, U$16.K, U$17.K, U$19.P$2, U$24.P$2

Notes on the sheet:
20m 3w rs品番6934384
0.47u以上
deadタイムは約600nsec
内部PWMは30k
csnとcspはできるだけ同じ長さで同じルート・無理にくねくねさせるなら同じながさでなくていい
ピンソケット
X7Rなどの特性のよいものをつかうこと
fetを変えた場合はそのfetのゲート容量によってブートストラップコンデンサを変えること
rs品番843-2168の820uFのコンデンサ
F_C*のコンデンサは0.33uFのフィルムコンデンサ
fetにSQD50034ELを使う。同じto252
電流制限は30Aに設定されている。refの抵抗比を変えることで変更可
fetのドレインソース間がオン時に1Vを超えたら短絡とみなされる
22Ωの抵抗器は1206の0.66W。rs品番721-9680

Board: 2 copper layers, 85.0 x 50.8 mm, 93 parts (44 on the bottom side), 60 nets.

## Commit log

2020-09-23 ブラシレスモタドラ
    別途インターフェース基板を作らないと動きません
2020-09-28 開発途中
2020-09-29 一応完成したもの
    fetにスナバ回路を加えることによりモーターサージを吸収できるようにした。ゲート・ソース間にコンデンサを入れられるようにして、セルフターンオンしないように細かく調整できるようにした。デッドタイムの設計を変え忘れた。確か47kΩでデッドタイムが700nSecほどになる。空冷するためのファン用のコネクタを追加した。還流ダイオードを入れるスペースが作れなかった。この設計で実験し思う性能が出せない場合は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
2020-09-29 フィードバックを受けて修正したもの
    スナバを大幅に修正して非放電型スナバにした。これにより抵抗器の損失を少なくできるため小型の抵抗器が使えるようになった。スナバに使っていたダイオードを還流ダイオードに使用して、スナバのダイオードは小さめのものに変えた。電流センサ用の配線をくねくねしないで揃うように頑張った。非放電型スナバの周りの配線が複雑になって怪しい気がするのでチェックお願いします。
2020-09-30 配線修正
    シャントの配線をしっかり切り分ける。
2020-10-01 完成品
    配線の修正などをおこなった
2020-10-07 スケマティックの抵抗の値がおかしかったので更新した
2020-10-07 スケマチックの抵抗の値がおかしかった
2020-10-17 エンハンスドver
2020-10-22 シャント抵抗ラインにローパスフィルタの追加
    電流制限、電流測定がつかいもんにならんかったからノイズを消すためにローパスフィルタをシャント抵抗の電位差を測るラインに追加
2020-11-19 ブラシレスモータインタフェース基板
    3.3vだけで動作するように昇圧回路のっけてたけど無駄だからやめた
